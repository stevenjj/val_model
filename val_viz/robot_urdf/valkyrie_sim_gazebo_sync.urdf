Commit message: fix mesh visualization

File: val_viz/robot_urdf/valkyrie_sim_gazebo_sync.urdf (robot description, URDF)
Before this commit: robot valkyrie, 80 links, 79 joints
Links:
- link leftHipRollLink: geometry visual mesh filename=package://val_desc/model/meshes/legs/lj2_left.dae
